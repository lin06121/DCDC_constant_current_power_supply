# Keil uVision project boot_demo_emac_flash.uvprojx, settings and files
target boot_demo_emac_flash (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: boot_demo_emac_flash
  AfterMake: fromelf --bin --output .\rvmdk\boot_demo_emac_flash.bin .\rvmdk\boot_demo_emac_flash.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA2 USE_FLASH_BOOT_LOADER
  c misc: --c99
  c include: .;..;..\..\..\..;..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include;..\..\..\..\third_party\lwip-1.4.1\src\include;..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: boot_demo_emac_flash.sct
  link misc: --entry Reset_Handler
  group Source
    ./: boot_demo_emac_flash.c startup_rvmdk.S
    ../../../../utils/: lwiplib.c swupdate.c ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
software components: CMSIS:CORE 5.6.0
