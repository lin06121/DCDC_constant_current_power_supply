# Keil uVision project enet_weather.uvproj, settings and files
target enet_weather (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: enet_weather
  AfterMake: fromelf --bin --output .\rvmdk\enet_weather.bin .\rvmdk\enet_weather.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA2 LWIP_1_4_1 USE_HTTP_1_0 UART_BUFFERED
  c misc: --c99
  c include: .;..;..\..\..\..;..\..\..\..\third_party\lwip-1.4.1\apps;..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include;..\..\..\..\third_party\lwip-1.4.1\src\include;..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4;..\..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: enet_weather.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../../utils/: cmdline.c flash_pb.c locator.c lwiplib.c uartstdio.c ustdlib.c
    ./: commands.c enet_weather.c eth_client.c images.c json.c startup_rvmdk.S
    ../drivers/: pinout.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
