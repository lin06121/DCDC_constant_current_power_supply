# Keil uVision project ssi_master_slave_xfer.uvproj, settings and files
target ssi_master_slave_xfer (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: ssi_master_slave_xfer
  AfterMake: fromelf --bin --output .\rvmdk\ssi_master_slave_xfer.bin .\rvmdk\ssi_master_slave_xfer.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA2
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: ssi_master_slave_xfer.sct
  link misc: --entry Reset_Handler
  group Source
    ./: ssi_master_slave_xfer.c startup_rvmdk.S
    ../../../../utils/: uartstdio.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
