# Keil uVision project usb_host_msc.uvproj, settings and files
target usb_host_msc (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: usb_host_msc
  AfterMake: fromelf --bin --output .\rvmdk\usb_host_msc.bin .\rvmdk\usb_host_msc.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA2
  c misc: --c99
  c include: ..;..\..\..\..;..\..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: usb_host_msc.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../../utils/: cmdline.c uartstdio.c ustdlib.c
    ../../../../third_party/fatfs/port/: fat_usbmsc.c
    ../../../../third_party/fatfs/src/: ff.c
    ../drivers/: pinout.c
    ./: startup_rvmdk.S usb_host_msc.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
