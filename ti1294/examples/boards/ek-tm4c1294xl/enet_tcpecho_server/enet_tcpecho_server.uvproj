# Keil uVision project enet_tcpecho_server.uvproj, settings and files
target enet_tcpecho_server (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: enet_tcpecho_server
  AfterMake: fromelf --bin --output .\rvmdk\enet_tcpecho_server.bin .\rvmdk\enet_tcpecho_server.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA2 DEBUG_OUTPUT UIP_OFFLOAD_ICMP_CHKSUM
  c misc: --c99
  c include: .;..;..\..\..\..;..\..\..\..\third_party\lwip-1.4.1\apps;..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include;..\..\..\..\third_party\lwip-1.4.1\src\include;..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4;..\..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: enet_tcpecho_server.sct
  link misc: --entry Reset_Handler
  group Source
    ./: enet_tcpecho_server.c startup_rvmdk.S
    ../../../../utils/: lwiplib.c uartstdio.c ustdlib.c
    ../drivers/: pinout.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
