# Keil uVision project usb_dev_cdcserial.uvproj, settings and files
target usb_dev_cdcserial (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: usb_dev_cdcserial
  AfterMake: fromelf --bin --output .\rvmdk\usb_dev_cdcserial.bin .\rvmdk\usb_dev_cdcserial.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT UART_BUFFERED TARGET_IS_TM4C129_RA2
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: usb_dev_cdcserial.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: pinout.c
    ./: startup_rvmdk.S usb_dev_cdcserial.c usb_structs.c
    ../../../../utils/: ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
