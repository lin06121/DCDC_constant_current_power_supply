# Keil uVision project boot_demo_uart_rom.uvproj, settings and files
target boot_demo_uart_rom (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: boot_demo_uart_rom
  AfterMake: fromelf --bin --output .\rvmdk\boot_demo_uart_rom.bin .\rvmdk\boot_demo_uart_rom.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA2
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: boot_demo_uart_rom.sct
  link misc: --entry Reset_Handler
  group Source
    ./: boot_demo_uart_rom.c startup_rvmdk.S
    ../drivers/: buttons.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
