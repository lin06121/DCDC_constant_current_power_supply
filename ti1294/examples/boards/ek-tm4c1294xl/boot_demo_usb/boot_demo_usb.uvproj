# Keil uVision project boot_demo_usb.uvproj, settings and files
target boot_demo_usb (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: boot_demo_usb
  AfterMake: fromelf --bin --output .\rvmdk\boot_demo_usb.bin .\rvmdk\boot_demo_usb.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA2
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: boot_demo_usb.sct
  link misc: --entry Reset_Handler
  group Source
    ./: boot_demo_usb.c startup_rvmdk.S usb_hiddfu_structs.c
    ../drivers/: buttons.c pinout.c
    ../../../../utils/: uartstdio.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
