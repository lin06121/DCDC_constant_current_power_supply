# Keil uVision project boot_emac_flash.uvprojx, settings and files
target boot_emac_flash (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: boot_emac_flash
  BeforeMake: armcc --device DLM -I . -E -o bl_config.inc ..\..\..\..\boot_loader\bl_config.c
  AfterMake: fromelf --bin --output .\rvmdk\boot_emac_flash.bin .\rvmdk\boot_emac_flash.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA2
  c misc: --c99
  c include: .;..\..\..\..;..\..\..\..\boot_loader
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: ..\..\..\..\boot_loader\bl_link.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../../boot_loader/: bl_autobaud.c bl_can.c bl_check.c bl_crc32.c bl_decrypt.c bl_emac.c bl_flash.c bl_i2c.c bl_main.c bl_packet.c bl_ssi.c bl_startup_rvmdk.S bl_uart.c bl_usb.c bl_usbfuncs.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ../../../../boot_loader/: readme.txt
software components: CMSIS:CORE 5.6.0
