# Keil uVision project EXP0.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: TM4C129CNCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EXP0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PART_TM4C1294NCPDT
  c include: .\inc;.\driverlib
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: exp0.c tm1638.c tm1638.h uart_debug.c uart_debug.h DAC6571.c DAC6571.h
    ./driverlib/rvmdk/: driverlib.lib
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 5.3.0, Device:Startup 1.0.0
